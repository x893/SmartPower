# Keil uVision project SmartPower.uvprojx, settings and files
target SmartPower (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SmartPower
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB
  c include: ../Inc;           ../Drivers/STM32L1xx_HAL_Driver/Inc;           ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Include;           ../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x8080000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rcc.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_crc.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Application/User
    ../Src/: main.c rtc.c stm32l1xx_it.c stm32l1xx_hal_msp.c gpio.c adc.c i2c.c i2c_board.c usart.c usart_board.c tim.c MAX5400.c MAX9611.c MAX5380.c MAX1169.c crc.c
    ../src/: MAX16936.c eeprom.c
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0
